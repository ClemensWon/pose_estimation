Commit message: final changes

File: pose_estimation/urdf/cube copy.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- removed link cylinder_link
- added link cube_link, mass 0.1; collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
